## configs/kroswan_defconfig
```kconfig
CONFIG_PLATFORM_KROSWAN=y

CONFIG_ESTIMATOR_AUTO_SELECT=y
CONFIG_CONTROLLER_AUTO_SELECT=y
```
